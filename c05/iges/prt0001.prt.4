# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M010) (file prt0001.prt.4)

Parameters:
  PTC_COMMON_NAME = "prt0001.prt"