# Pro/ENGINEER part, saved by Pro/ENGINEER Wildfire 2.0 (M010) (file sweep_mesh_example02.prt.17)

Parameters:
  PTC_COMMON_NAME = "sweep_mesh_example02.prt"